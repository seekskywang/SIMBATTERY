# Keil uVision project project.uvprojx, settings and files
target Open1788 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: E:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o ..\update\update.bin Output\project.axf
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\Libraries\Core\CM3\CoreSupport;..\Libraries\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\Libraries\Drivers\include;..\User;..\Libraries\BoardSupport;..\User\UseDisp;..\User\Globalvalue;..\User\Include;..\User\Fat;..\User\Host;..\User\MassStorage;..\User\rtc;..\Libraries\Drivers\include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../User/EX_SDRAM/: EX_SDRAM.c
    ../User/: main.c timer.c
    ../User/LCD/: lpc177x_8x_lcd.c logo.c AsciiLib.c
    ../User/TouchPanel/: TouchPanel.c
    ../User/UseDisp/: use_disp.c
    ../User/Test/: test.c
    ../User/Globalvalue/: GlobalValue.c
    ../Libraries/Drivers/source/: lpc177x_8x_rtc.c
    ../User/Key/: key.c
    ../User/rtc/: rtc.c
    ../User/DMA/: dma.c
  group Startup
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS-CMS
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    ../Libraries/Core/CM3/CoreSupport/: core_cm3.c
  group Drivers
    ../Libraries/Drivers/source/: lpc177x_8x_gpio.c lpc177x_8x_systick.c lpc177x_8x_clkpwr.c lpc177x_8x_ssp.c lpc177x_8x_uart.c debug_frmwrk.c lpc177x_8x_pinsel.c lpc177x_8x_eeprom.c lpc177x_8x_gpdma.c
  group fat
    ../User/Fat/: usbhost_fat.c
  group host
    ../User/Host/: usbhost_lpc17xx.c
  group MassStorage
    ../User/MassStorage/: usbhost_ms.c
